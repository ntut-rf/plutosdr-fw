options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: dvbt_2k_trx_demo_gcs_qpsk
    output_language: python
  states: {}

blocks:
- name: RX_gain
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '89'
    value: '35'
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: 900e6
  states: {}
- name: paylod_size
  id: variable
  parameters:
    value: '1500'
  states: {}
- name: samp_rate_video
  id: variable
  parameters:
    value: 32e5
  states: {}
- name: tx_gain
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '89'
    value: '65'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: dvbt_2k_trx_demo_uav_qpsk.bin
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate_video
    type: complex
  states: {}
- name: blocks_udp_sink_0
  id: blocks_udp_sink
  parameters:
    eof: 'True'
    ipaddr: 127.0.0.1
    port: '6000'
    psize: paylod_size
    type: byte
    vlen: '1'
  states: {}
- name: blocks_vector_to_stream_1
  id: blocks_vector_to_stream
  parameters:
    num_items: '1512'
    type: byte
  states: {}
- name: dtv_dvbt_bit_inner_deinterleaver_0
  id: dtv_dvbt_bit_inner_deinterleaver
  parameters:
    constellation: qpsk
    transmission_mode: T2k
  states: {}
- name: dtv_dvbt_convolutional_deinterleaver_0
  id: dtv_dvbt_convolutional_deinterleaver
  parameters:
    I: '12'
    M: '17'
    blocks: '136'
  states: {}
- name: dtv_dvbt_demap_0
  id: dtv_dvbt_demap
  parameters:
    constellation: qpsk
    gain: '1'
    hierarchy: nh
    transmission_mode: T2k
  states: {}
- name: dtv_dvbt_demod_reference_signals_0
  id: dtv_dvbt_demod_reference_signals
  parameters:
    cell_id: '0'
    code_rate_hp: C1_2
    code_rate_lp: C1_2
    constellation: qpsk
    guard_interval: GI_1_32
    hierarchy: nh
    include_cell_id: call_id_yes
    transmission_mode: T2k
    type: complex
  states: {}
- name: dtv_dvbt_energy_descramble_0
  id: dtv_dvbt_energy_descramble
  parameters:
    nsize: '8'
  states: {}
- name: dtv_dvbt_ofdm_sym_acquisition_0
  id: dtv_dvbt_ofdm_sym_acquisition
  parameters:
    cp_length: '256'
    fft_length: '2048'
    occupied_tones: '1905'
    snr: '20'
    type: complex
  states: {}
- name: dtv_dvbt_reed_solomon_dec_0
  id: dtv_dvbt_reed_solomon_dec
  parameters:
    blocks: '8'
    gfpoly: '0x11d'
    k: '239'
    m: '8'
    n: '255'
    p: '2'
    s: '51'
    t: '8'
  states: {}
- name: dtv_dvbt_symbol_inner_interleaver_1
  id: dtv_dvbt_symbol_inner_interleaver
  parameters:
    direction: Deinterleave
    transmission_mode: T2k
  states: {}
- name: dtv_dvbt_viterbi_decoder_0
  id: dtv_dvbt_viterbi_decoder
  parameters:
    block_size: '768'
    code_rate: C1_2
    constellation: qpsk
    hierarchy: nh
    type: b
  states: {}
- name: fft_vxx_1
  id: fft_vxx
  parameters:
    fft_size: '2048'
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.rectangular(2048)
  states: {}
- name: pluto_source_0
  id: pluto_source
  parameters:
    auto_filter: 'True'
    bandwidth: '20000000'
    bbdc: 'True'
    buffer_size: '0x8000'
    filter: ''
    frequency: int(center_freq)
    gain: '"manual"'
    manual_gain: '32'
    quadrature: 'True'
    rfdc: 'True'
    samplerate: int(samp_rate_video)
    uri: ''
  states: {state: disabled}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate_video
    fc: '0'
    fftsize: '1024'
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: uhd_usrp_sink_0_0
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    center_freq0: 900e6
    clock_rate: '0.0'
    dev_addr: serial=318423F
    dev_args: '"master_clock_rate=256e5"'
    gain0: tx_gain
    len_tag_name: ''
    norm_gain0: 'False'
    samp_rate: samp_rate_video
    sync: sync
    type: fc32
  states: {state: disabled}

connections:
- [blocks_file_source_0, '0', blocks_throttle_0, '0']
- [blocks_file_source_0, '0', uhd_usrp_sink_0_0, '0']
- [blocks_throttle_0, '0', dtv_dvbt_ofdm_sym_acquisition_0, '0']
- [blocks_throttle_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_vector_to_stream_1, '0', dtv_dvbt_viterbi_decoder_0, '0']
- [dtv_dvbt_bit_inner_deinterleaver_0, '0', blocks_vector_to_stream_1, '0']
- [dtv_dvbt_convolutional_deinterleaver_0, '0', dtv_dvbt_reed_solomon_dec_0, '0']
- [dtv_dvbt_demap_0, '0', dtv_dvbt_symbol_inner_interleaver_1, '0']
- [dtv_dvbt_demod_reference_signals_0, '0', dtv_dvbt_demap_0, '0']
- [dtv_dvbt_energy_descramble_0, '0', blocks_udp_sink_0, '0']
- [dtv_dvbt_ofdm_sym_acquisition_0, '0', fft_vxx_1, '0']
- [dtv_dvbt_reed_solomon_dec_0, '0', dtv_dvbt_energy_descramble_0, '0']
- [dtv_dvbt_symbol_inner_interleaver_1, '0', dtv_dvbt_bit_inner_deinterleaver_0, '0']
- [dtv_dvbt_viterbi_decoder_0, '0', dtv_dvbt_convolutional_deinterleaver_0, '0']
- [fft_vxx_1, '0', dtv_dvbt_demod_reference_signals_0, '0']
- [pluto_source_0, '0', dtv_dvbt_ofdm_sym_acquisition_0, '0']
- [pluto_source_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
