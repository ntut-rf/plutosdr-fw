options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: dvbt_2k_trx_demo_uav_qpsk
    output_language: python
  states: {}

blocks:
- name: Rxgain
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    rangeType: int
    start: '0'
    step: '1'
    stop: '90'
    value: '20'
  states: {state: disabled}
- name: center_freq
  id: variable
  parameters:
    value: 900e6
  states: {}
- name: paylod_size
  id: variable
  parameters:
    value: '1500'
  states: {}
- name: samp_rate_gmsk
  id: variable
  parameters:
    value: 100e3
  states: {state: disabled}
- name: samp_rate_video
  id: variable
  parameters:
    value: 32e5
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: dvbt_2k_trx_demo_uav_qpsk.bin
    type: complex
    unbuffered: 'True'
  states: {}
- name: blocks_multiply_const_xx_0
  id: blocks_multiply_const_xx
  parameters:
    const: '0.0022097087'
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate_video
    type: complex
  states: {}
- name: blocks_udp_source_0
  id: blocks_udp_source
  parameters:
    eof: 'True'
    ipaddr: 127.0.0.1
    port: '5000'
    psize: paylod_size
    type: byte
    vlen: '1504'
  states: {state: disabled}
- name: blocks_vector_sink_x_0
  id: blocks_vector_sink_x
  parameters:
    type: byte
    vlen: '1504'
  states: {state: disabled}
- name: digital_ofdm_cyclic_prefixer_0
  id: digital_ofdm_cyclic_prefixer
  parameters:
    cp_len: '256'
    input_size: '2048'
    tagname: ''
  states: {}
- name: dtv_dvbt_bit_inner_interleaver_0
  id: dtv_dvbt_bit_inner_interleaver
  parameters:
    constellation: qpsk
    transmission_mode: T2k
  states: {}
- name: dtv_dvbt_convolutional_interleaver_0
  id: dtv_dvbt_convolutional_interleaver
  parameters:
    I: '12'
    M: '17'
    blocks: '136'
  states: {}
- name: dtv_dvbt_energy_dispersal_0
  id: dtv_dvbt_energy_dispersal
  parameters:
    nsize: '1'
  states: {}
- name: dtv_dvbt_inner_coder_0
  id: dtv_dvbt_inner_coder
  parameters:
    code_rate: C1_2
    constellation: qpsk
    hierarchy: nh
    ninput: '1'
    noutput: '1512'
  states: {}
- name: dtv_dvbt_map_0
  id: dtv_dvbt_map
  parameters:
    constellation: qpsk
    gain: '1'
    hierarchy: nh
    transmission_mode: T2k
  states: {}
- name: dtv_dvbt_reed_solomon_enc_0
  id: dtv_dvbt_reed_solomon_enc
  parameters:
    blocks: '8'
    gfpoly: '0x11d'
    k: '239'
    m: '8'
    n: '255'
    p: '2'
    s: '51'
    t: '8'
  states: {}
- name: dtv_dvbt_reference_signals_0
  id: dtv_dvbt_reference_signals
  parameters:
    cell_id: '0'
    code_rate_hp: C1_2
    code_rate_lp: C1_2
    constellation: qpsk
    guard_interval: GI_1_32
    hierarchy: nh
    include_cell_id: call_id_yes
    transmission_mode: T2k
    type: complex
  states: {}
- name: dtv_dvbt_symbol_inner_interleaver_0
  id: dtv_dvbt_symbol_inner_interleaver
  parameters:
    direction: Interleave
    transmission_mode: T2k
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: '2048'
    forward: 'False'
    shift: 'True'
    type: complex
    window: window.rectangular(2048)
  states: {}
- name: plutosdr_dvbt_energy_dispersal_0
  id: plutosdr_dvbt_energy_dispersal
  parameters: {}
  states: {state: disabled}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate_video
    fc: center_freq
    fftsize: '1024'
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: video_src_0
  id: video_src
  parameters: {}
  states: {}

connections:
- [blocks_multiply_const_xx_0, '0', blocks_file_sink_0, '0']
- [blocks_multiply_const_xx_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_throttle_0, '0', blocks_multiply_const_xx_0, '0']
- [blocks_udp_source_0, '0', dtv_dvbt_energy_dispersal_0, '0']
- [blocks_udp_source_0, '0', dtv_dvbt_reed_solomon_enc_0, '0']
- [digital_ofdm_cyclic_prefixer_0, '0', blocks_throttle_0, '0']
- [dtv_dvbt_bit_inner_interleaver_0, '0', dtv_dvbt_symbol_inner_interleaver_0, '0']
- [dtv_dvbt_convolutional_interleaver_0, '0', dtv_dvbt_inner_coder_0, '0']
- [dtv_dvbt_energy_dispersal_0, '0', dtv_dvbt_reed_solomon_enc_0, '0']
- [dtv_dvbt_inner_coder_0, '0', dtv_dvbt_bit_inner_interleaver_0, '0']
- [dtv_dvbt_map_0, '0', dtv_dvbt_reference_signals_0, '0']
- [dtv_dvbt_reed_solomon_enc_0, '0', dtv_dvbt_convolutional_interleaver_0, '0']
- [dtv_dvbt_reference_signals_0, '0', fft_vxx_0, '0']
- [dtv_dvbt_symbol_inner_interleaver_0, '0', dtv_dvbt_map_0, '0']
- [fft_vxx_0, '0', digital_ofdm_cyclic_prefixer_0, '0']
- [plutosdr_dvbt_energy_dispersal_0, '0', blocks_vector_sink_x_0, '0']
- [plutosdr_dvbt_energy_dispersal_0, '0', dtv_dvbt_reed_solomon_enc_0, '0']
- [video_src_0, '0', dtv_dvbt_energy_dispersal_0, '0']

metadata:
  file_format: 1
